# Keil uVision project project.uvprojx, settings and files
target f303nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xe,
  c include: ..\Library\CMSIS\Device\ST\STM32F30x\Include;..\Library\CMSIS\Include;..\Library\STM32F30x_StdPeriph_Driver\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\User\peripheral_device_h;..\User\delay;..\User\bsp_key;..\User\bsp_led;..\User\bsp_usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Library/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f303xe.s
  group CMSIS
    ../Library/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group STM32F30x_StdPeriph_Driver
    ../Library/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group USER
    ../User/: FreeRTOSConfig.h main.c stm32f30x_it.c
    ../User/peripheral_device_c/: peripheral_device.c manual_controller.c lamp.c airconditioner.c alarm.c co2_generator.c ventilator.c water_sprayer.c oled.c uln2003_28BYJ_48.c sensor_L432.c i2c_gpio.c
    ../User/bsp_usart/: bsp_usart.c
    ../User/bsp_key/: bsp_key.c
    ../User/bsp_led/: bsp_led.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
